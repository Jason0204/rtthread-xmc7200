# Keil uVision project project.uvprojx, settings and files
target rtthread (6180000::V6.18::ARMCLANG)
  device: XMC7200D-E272K8384:Cortex-M7-0 Infineon
  pack: Infineon.CAT1C_DFP.1.0.0
  cpu: IRAM(0x28000000,0x100000) IROM(0x10000000,0x830000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: C:\Keil_v5\ARM\ARM_Compiler_5.06u7\bin\fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: __STDC_LIMIT_MACROS, CY_SUPPORTS_DEVICE_VALIDATION, COMPONENT_MW_RETARGET_IO, XMC7200D_E272K8384, CY_TARGET_BOARD=APP_KIT_XMC72_EVK, COMPONENT_CM7, DEBUG, CORE_NAME_CM7_0=1, RT_USING_LIBC, CY_USING_HAL, RT_USING_ARMLIBC, COMPONENT_CAT1C, COMPONENT_MW_MTB_HAL_CAT1, COMPONENT_APP_KIT_XMC72_EVK, COMPONENT_MW_CAT1CM0P, COMPONENT_MW_MTB_PDL_CAT1, COMPONENT_CAT1C8M, COMPONENT_XMC7x_CM0P_SLEEP, TARGET_APP_KIT_XMC72_EVK, CYBSP_WIFI_WL_REG_ON_GPIO_DRIVE_MODE=CYHAL_GPIO_DRIVE_STRONG, COMPONENT_SOFTFP, __CLK_TCK=RT_TICK_PER_SECOND, COMPONENT_DebugCOMPONENT_GCC_ARM, COMPONENT_MW_CORE_LIB, COMPONENT_MW_RECIPE_MAKE_CAT1C, COMPONENT_MW_CORE_MAKE, COMPONENT_MW_CMSIS, COMPONENT_CM7_0, COMPONENT_CAT1, __RTTHREAD__
  c include: ..\..\..\components\drivers\include;packages\Infineon_mtb-pdl-cat1-latest\devices\COMPONENT_CAT1C\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\compilers\common\include;packages\Infineon_mtb-hal-cat1-latest\include_pvt;packages\Infineon_cat1cm0p-latest\COMPONENT_CAT1C;packages\Infineon_mtb-hal-cat1-latest\COMPONENT_CAT1C\include;libs\TARGET_APP_KIT_XMC72_EVK\config\GeneratedSource;packages\Infineon_cmsis-latest\Core\Include;packages\Infineon_core-lib-latest\include;board\ports;packages\Infineon_mtb-hal-cat1-latest\COMPONENT_CAT1C\include\triggers;.;..\libraries\HAL_Drivers;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\config;packages\Infineon_mtb-hal-cat1-latest\include;..\..\..\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\finsh;packages\Infineon_mtb-pdl-cat1-latest\devices\COMPONENT_CAT1C\include\ip;packages\Infineon_mtb-hal-cat1-latest\COMPONENT_CAT1C\include\pin_packages;..\..\..\components\libc\posix\io\epoll;packages\Infineon_retarget-io-latest;..\..\..\components\drivers\include;packages\Infineon_mtb-pdl-cat1-latest\drivers\third_party\ethernet\include;..\..\..\components\libc\posix\io\poll;board;packages\Infineon_mtb-pdl-cat1-latest\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;applications;..\..\..\components\libc\posix\ipc;libs\TARGET_APP_KIT_XMC72_EVK
  memory RVCT4: ROM 0x10000000 size 0x830000
  memory RVCT9: RAM 0x28000000 size 0x100000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    packages/Infineon_mtb-pdl-cat1-latest/drivers/source/TOOLCHAIN_ARM/: cy_syslib_ext.s
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c cmd.c msh_parse.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    packages/Infineon_cat1cm0p-latest/COMPONENT_CAT1C/COMPONENT_XMC7x_CM0P_SLEEP/: xmc7100_cm0p_sleep.c xmc7200_cm0p_sleep.c
    packages/Infineon_mtb-hal-cat1-latest/COMPONENT_CAT1C/source/pin_packages/: cyhal_xmc7200_272_bga.c
    packages/Infineon_mtb-hal-cat1-latest/COMPONENT_CAT1C/source/triggers/: cyhal_triggers_xmc7200.c
    packages/Infineon_mtb-hal-cat1-latest/source/: cyhal_clock.c cyhal_dma.c cyhal_dma_dmac.c cyhal_dma_dw.c cyhal_gpio.c cyhal_hwmgr.c cyhal_interconnect.c cyhal_irq_impl.c cyhal_lptimer.c cyhal_scb_common.c cyhal_syspm.c cyhal_system.c cyhal_uart.c cyhal_utils.c cyhal_utils_impl.c
    packages/Infineon_mtb-pdl-cat1-latest/devices/COMPONENT_CAT1C/source/: cy_device.c
    packages/Infineon_mtb-pdl-cat1-latest/drivers/source/: cy_dma.c cy_dmac.c cy_gpio.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c cy_mcwdt.c cy_mcwdt_b.c cy_prot.c cy_scb_common.c cy_scb_i2c.c cy_scb_uart.c cy_sysclk.c cy_sysclk_v2.c cy_sysint.c cy_syslib.c cy_syspm.c cy_syspm_v3.c cy_systick.c cy_trigmux.c cy_wdt_b.c
    packages/Infineon_retarget-io-latest/: cy_retarget_io.c
  group libs
    libs/TARGET_APP_KIT_XMC72_EVK/config/GeneratedSource/: cycfg.c cycfg_qspi_memslot.c cycfg_system.c cycfg_clocks.c cycfg_peripherals.c cycfg_pins.c
    libs/TARGET_APP_KIT_XMC72_EVK/: cybsp.c
    libs/TARGET_APP_KIT_XMC72_EVK/COMPONENT_CM7/: system_cm7.c startup_cm7.c
